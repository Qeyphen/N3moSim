Commit message: patch: remove redundant docs

File: config/usv.urdf (robot description, URDF)
Before this commit: robot usv, 2 links, 1 joints
Joints:
- joint camera_mount: origin xyz=3 0 1 rpy=0 0 0 -> xyz=3 10 0 rpy=0 0 0
